
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://austin-include_mtd_headers.patch  \
			"

